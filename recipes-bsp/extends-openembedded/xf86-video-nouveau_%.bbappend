COMPATIBLE_HOST = '(x86_64.*|i.86.*|powerpc.*|powerpc64.*)-(linux|freebsd.*)' 


